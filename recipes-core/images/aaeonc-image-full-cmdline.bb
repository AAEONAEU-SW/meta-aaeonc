DESCRIPTION = "Linux image for AAEON Community family boards based on core-image-full-cmdline"
LICENSE = "GPLv2"

require aaeonc-image.inc
require recipes-extended/images/core-image-full-cmdline.bb
