require recipes-kernel/linux/linux-aaeonc.inc

